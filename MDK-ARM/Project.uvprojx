# Keil uVision project Project.uvprojx, settings and files
target sram (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project +hex
  AfterMake: fromelf app-sram\%L --bin --output=app-sram\bin\sram.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F769xx,USE_STM32F769I_DISCO,STM32_SDK,APPLICATION,__ARCH_ARM_M7__
  c misc: --no_unaligned_access
  c include: ..\Inc;..\doom\src;..\doom\src\chocdoom;..\ulib\pub;..\ulib\arch;..\configs\stm32f769-disco
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\application_sram.sct
  group Example/MDK-ARM
    ./: startup.s
  group Example/User
    ../Src/: main.c stm32f7xx_it.c
    ../doom/src/: dd_main.c i_sdlsound.c
  group doom
    ../doom/src/chocdoom/: am_map.c d_event.c d_items.c d_iwad.c d_loop.c d_main.c d_mode.c d_net.c doomdef.c doomstat.c dstrings.c dummy.c f_finale.c f_wipe.c g_game.c hu_lib.c hu_stuff.c i_cdmus.c i_endoom.c i_joystick.c i_main.c i_scale.c i_sound.c i_system.c i_timer.c i_video.c i_videohr.c info.c m_argv.c m_bbox.c m_cheat.c m_config.c m_controls.c m_fixed.c m_menu.c m_misc.c m_random.c memio.c p_ceilng.c p_doors.c p_enemy.c p_floor.c p_inter.c p_lights.c p_map.c p_maputl.c p_mobj.c p_plats.c p_pspr.c p_saveg.c p_setup.c p_sight.c p_spec.c p_switch.c p_telept.c p_tick.c p_user.c r_bsp.c r_data.c r_draw.c r_main.c r_plane.c r_segs.c r_sky.c r_things.c s_sound.c sha1.c sounds.c st_lib.c st_stuff.c statdump.c tables.c v_video.c w_checksum.c w_file.c w_file_stdc.c w_main.c w_wad.c wi_stuff.c z_zone.c w_merge.c
    ../doom/src/: global.c
  group app
    ../ulib/pub/: dev_main.c bsp_api.c
    ../ulib/lib/: dstring.c dmalloc.c dmisc.c
    ../ulib/mem/: heap.c
    ../ulib/arch/Arm/m7/src/: machM7.s asm_utils.s
    ../common/STM32H7xx_Driver/BSP/STM32H747I-DISCO/: system_stm32h7xx.c
    ../common/STM32F7xx_Driver/BSP/STM32F769I-Discovery/: system_stm32f7xx.c
target sram-h7 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf app-sram\%L --bin --output=app-sram\bin\sram.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H747xx,USE_STM32H747I_DISCO,STM32_SDK,APPLICATION,__ARCH_ARM_M7__
  c misc: --no_unaligned_access
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\application_sram-h7.sct
software components: CMSIS:CORE 5.0.1
